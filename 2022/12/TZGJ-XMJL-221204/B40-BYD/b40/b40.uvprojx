# Keil uVision project b40.uvprojx, settings and files
target b40 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: BF7006AM64 Generic
  pack: BYD.BYDMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x18000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: b40 +hex
  AfterMake: $L..\PackScript\RunAfterBulid.bat $K @L $L #L B40Bootloader
  c flags: Optim=3 oTime=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\pt;.\src;.\config
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\src\link.sct
  link misc: --keep  startup_BF7006AMxx.o(RESETORGIN)
  group app
    ./src/: OrderConfig.h adc.c adc.h base.h BF7006AMxx_it.c bootloader.c can_protol.c can_protol.h config.h eeprom.c eeprom.h main.c includes.h pluse.c pluse.h power_out.c power_out.h rain.c rain.h switch.c switch.h tsi.c param.c power.c init_section.c defs.h ringfifo.c ringfifo.h canhl.c canhl.h logic.c logic1.c logic2.c logic3.c logic4.c save.h logic5.c logic.h
  group ext
    ./src/: link.sct
    ./PackScript/: RunAfterBulid.bat
software components: CMSIS:CORE 5.4.0, CMSIS:BF7x06 Header 1.0.0, Device:Peripheral Driver:ADC 1.0.2, Device:Peripheral Driver:CAN 1.0.2, Device:Peripheral Driver:EFlash 1.0.3, Device:Peripheral Driver:GPIO 1.0.2, Device:Peripheral Driver:PWM 1.0.3, Device:Peripheral Driver:RTC 1.0.2, Device:Peripheral Driver:Timer 1.0.2, Device:Peripheral Driver:Watch Dog Timer 1.0.2, Device:System Control 1.0.3, SEGGER:RTT 1.0.0, Startup:Startup 1.0.0
