# Keil uVision project b40Bootloader.uvprojx, settings and files
target b40Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BF7006AM64 Generic
  pack: BYD.BYDMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x18000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: b40bootloader +hex
  AfterMake: custom.bat $K  #L
  c flags: Optim=2 oTime=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src\pt;.\src
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\link.sct
  link misc: --keep  *.o(KEYWORD)
  group app
    ./src/: base.h BF7006AMxx_it.c can_protol.c can_protol.h includes.h main.c canhl.c canhl.h ringfifo.c ringfifo.h
  group ext
    ./: custom.bat link.sct
software components: CMSIS:CORE 5.4.0, CMSIS:BF7x06 Header 1.0.0, Device:Peripheral Driver:CAN 1.0.2, Device:Peripheral Driver:EFlash 1.0.3, Device:Peripheral Driver:GPIO 1.0.2, Device:Peripheral Driver:Timer 1.0.2, Device:Peripheral Driver:Watch Dog Timer 1.0.2, Device:System Control 1.0.3, SEGGER:RTT 1.0.0, Startup:Startup 1.0.0
