# Keil uVision project T123_Demo_Code.uvproj, settings and files
target T123_Demo_Code (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: T123_Demo_Code +hex
  AfterMake: .\Object\Hex2BinBatch_64_lx51.bat T123_Demo_Code 49152
  c flags: Optimize=8 SizeSpeed=1
  c define: T123AI
  c include: .\IncludeFile;..\tw_lib\sys;..\tw_lib\drivers;.\resource;.\i51
  link misc: REMOVEUNUSED
  group Common
    ./SourceFile/: STARTUP.A51 c_root.c timer.c interrupt.c check_event.c version.c
    ../tw_lib/sys/: BANK_SWITCH.A51
  group Sys
    ../tw_lib/sys/: tw_irq.c get_eq.c iccontrol.c
  group Drivers
    ../tw_lib/drivers/: spirw.c spiosd.c osd2api.c cq.c serial.c tw_timer.c doprnt.c vivi.c rc.c i51_i2c_drivers.c
  group tw_widget_sys
    ../tw_lib/sys/: tw_widget_sys.c
    ./Source/: page_handler.c
  group Init
    ../tw_lib/sys/: tw_init.c
    ./SourceFile/: init.c panel.c vivitable.c
    ../tw_lib/drivers/: videodetect.c
  group Doc
    ./: Releas Note.txt
  group C50
    ./SourceFile/: display.c uart.c mydrivers.c dispages.c
  group bank1
    ./i51/: page_front_moudle_struct.c page_help_message_struct.c page_logo_struct.c page_main_internal_struct.c page_main_menus_struct.c page_meter_moudle_struct.c page_parameter_struct.c page_rear_moudle_struct.c page_start_struct.c page_surface1_struct.c page_surface2_struct.c page_surface3_struct.c page_surface4_struct.c page_surface5_struct.c page_surface6_struct.c page_video_struct.c page_surface7_struct.c page_surface8_struct.c page_surface9_struct.c page_surface10_struct.c page_surface11_struct.c page_surface12_struct.c page_surface13_struct.c page_surface14_struct.c page_surface15_struct.c page_top_moudle_struct.c page_surface16_struct.c page_surface17_struct.c page_surface18_struct.c page_surface19_struct.c page_surface20_struct.c page_surface21_struct.c
    ./Source/: page_front_moudle.c page_front_moudle_out.c page_help_message.c page_logo.c page_main_internal.c page_main_menus.c page_meter_moudle.c page_parameter.c page_rear_moudle.c page_rear_moudle_out.c page_start.c page_surface1.c page_surface2.c page_surface3.c page_surface4.c page_surface5.c page_surface6.c page_surface7.c page_surface8.c page_surface9.c page_surface10.c page_surface11.c page_surface12.c page_surface13.c page_surface14.c page_surface15.c page_surface16.c page_top_moudle.c page_top_moudle_out.c page_video.c page_surface17.c page_surface18.c page_surface19.c page_surface20.c page_surface21.c
